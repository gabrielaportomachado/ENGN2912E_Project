v {xschem version=3.4.7 file_version=1.2}
G {}
K {spice_stop=true}
V {}
S {}
E {}
C {ipin.sym} -60 -400 0 0 {name=p1 lab=A1}
C {iopin.sym} -110 -240 0 0 {name=p5 lab=VDD}
C {iopin.sym} -110 -190 0 0 {name=p6 lab=VNW}
C {iopin.sym} -110 -140 0 0 {name=p7 lab=VPW}
C {iopin.sym} -110 -90 0 0 {name=p8 lab=VSS}
C {opin.sym} -100 -280 0 0 {name=p4 lab=ZN}
C {ipin.sym} -60 -360 0 0 {name=p2 lab=A2}
C {ipin.sym} -60 -320 0 0 {name=p3 lab=A3}
