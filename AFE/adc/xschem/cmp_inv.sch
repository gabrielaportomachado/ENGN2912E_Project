v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {symbols/nfet_03v3.sym} -100 60 0 0 {name=n
L='0.28u'
W='WN'
nf=1
m=1
ad='WN*0.18u'
as='WN*0.18u'
pd='2*(WN+0.18u)'
ps='2*(WN+0.18u)'
nrd=0
nrs=0
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X}
C {lab_pin.sym} -80 30 0 1 {name=p1 sig_type=std_logic lab=o}
C {lab_pin.sym} -80 90 0 1 {name=p2 sig_type=std_logic lab=vss}
C {lab_pin.sym} -120 60 0 0 {name=p3 sig_type=std_logic lab=i}
C {lab_pin.sym} -80 60 0 1 {name=p4 sig_type=std_logic lab=vss}
C {symbols/pfet_03v3.sym} -100 -60 0 0 {name=p
L='0.28u'
W='WP'
nf=1
m=1
ad='WP*0.18u'
as='WP*0.18u'
pd='2*(WP+0.18u)'
ps='2*(WP+0.18u)'
nrd=0
nrs=0
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X}
C {lab_pin.sym} -80 -90 0 1 {name=p5 sig_type=std_logic lab=vdd}
C {lab_pin.sym} -80 -30 0 1 {name=p6 sig_type=std_logic lab=o}
C {lab_pin.sym} -120 -60 0 0 {name=p7 sig_type=std_logic lab=i}
C {lab_pin.sym} -80 -60 0 1 {name=p8 sig_type=std_logic lab=vdd}
C {ipin.sym} -300 -100 0 0 {name=io9 lab=i}
C {opin.sym} 700 -60 0 1 {name=io10 lab=o}
C {iopin.sym} -300 -20 0 0 {name=io11 lab=vdd}
C {iopin.sym} -300 20 0 0 {name=io12 lab=vss}
T {cmp_inv: minimum inverter used as clock inverter and output buffers (generated by scripts/gen_cmp_sch.py).} -700 -360 0 0 0.3 0.3 {}
