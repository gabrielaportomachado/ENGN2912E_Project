v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 50 -30 0 0 {name=p1 lab=I0}
C {ipin.sym} 50 20 0 0 {name=p2 lab=I1}
C {ipin.sym} 50 70 0 0 {name=p3 lab=S}
C {opin.sym} 50 120 0 0 {name=p4 lab=Z}
C {iopin.sym} 50 170 0 0 {name=p5 lab=VDD}
C {iopin.sym} 50 220 0 0 {name=p6 lab=VNW}
C {iopin.sym} 50 270 0 0 {name=p7 lab=VPW}
C {iopin.sym} 50 320 0 0 {name=p8 lab=VSS}
