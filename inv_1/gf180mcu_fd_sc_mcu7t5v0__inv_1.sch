v {xschem version=3.4.7 file_version=1.2}
G {}
K {spice_stop=true}
V {}
S {}
E {}
C {iopin.sym} -30 0 0 0 {name=p5 lab=VDD}
C {iopin.sym} -30 50 0 0 {name=p6 lab=VNW}
C {iopin.sym} -30 100 0 0 {name=p7 lab=VPW}
C {iopin.sym} -30 150 0 0 {name=p8 lab=VSS}
C {opin.sym} -20 -40 0 0 {name=p4 lab=ZN}
C {ipin.sym} 20 -80 0 0 {name=p2 lab=I}
