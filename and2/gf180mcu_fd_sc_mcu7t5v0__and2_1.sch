v {xschem version=3.4.7 file_version=1.2}
G {}
K {spice_stop=true}
V {}
S {}
E {}
C {ipin.sym} -90 -140 0 0 {name=p1 lab=A1}
C {iopin.sym} -140 -20 0 0 {name=p5 lab=VDD}
C {iopin.sym} -140 30 0 0 {name=p6 lab=VNW}
C {iopin.sym} -140 80 0 0 {name=p7 lab=VPW}
C {iopin.sym} -140 130 0 0 {name=p8 lab=VSS}
C {opin.sym} -130 -60 0 0 {name=p4 lab=Z}
C {ipin.sym} -90 -100 0 0 {name=p2 lab=A2}
