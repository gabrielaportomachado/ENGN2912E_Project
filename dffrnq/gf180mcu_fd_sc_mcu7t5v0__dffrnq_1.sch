v {xschem version=3.4.7 file_version=1.2}
G {}
K {spice_stop=true}
V {}
S {}
E {}
C {ipin.sym} -200 -100 0 0 {name=p1 lab=D}
C {ipin.sym} -200 -50 0 0 {name=p2 lab=RN}
C {ipin.sym} -200 0 0 0 {name=p3 lab=CLK}
C {opin.sym} -200 50 0 0 {name=p4 lab=Q}
C {iopin.sym} -200 100 0 0 {name=p5 lab=VDD}
C {iopin.sym} -200 150 0 0 {name=p6 lab=VNW}
C {iopin.sym} -200 200 0 0 {name=p7 lab=VPW}
C {iopin.sym} -200 250 0 0 {name=p8 lab=VSS}
